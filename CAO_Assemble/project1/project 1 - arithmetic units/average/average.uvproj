# Keil uVision project average.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051AH Intel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: average
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: average.a51 add32.inc mul16.inc
