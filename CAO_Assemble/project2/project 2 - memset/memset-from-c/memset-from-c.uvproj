# Keil uVision project memset-from-c.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80C51BH Intel
  cpu: IRAM(0-0x7F)  IROM(0-0xFFF) CLOCK(12000000)
  output: memset-from-c
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c cao_memset.a51
